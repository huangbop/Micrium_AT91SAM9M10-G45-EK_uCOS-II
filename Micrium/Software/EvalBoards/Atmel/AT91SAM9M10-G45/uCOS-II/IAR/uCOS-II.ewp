# IAR project uCOS-II.ewp, settings and files
configuration SRAM (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM9M10 Atmel AT91SAM9M10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\uCOS-II; ..\..\BSP; ..\..\BSP\IAR; ..\..\..\..\..\uC-LIB; ..\..\..\..\..\uC-CPU; ..\..\..\..\..\uC-CPU\ARM\IAR; ..\..\..\..\..\uCOS-II\Ports\ARM\Generic\IAR\; ..\..\..\..\..\uCOS-II\Ports\ARM\CSP\; ..\..\..\..\..\uCOS-II\Source; ..\..\..\..\..\uC-CSP\MCU; ..\..\..\..\..\uC-CSP\MCU\Atmel\AT91SAM9M10; ..\..\..\..\..\uC-CSP\MCU\Atmel\AT91SAM9M10\AT91SAM9M10; ..\..\..\..\..\uC-Serial\Source; ..\..\..\..\..\uC-Serial\Driver\Atmel\AT91SAM9M10; ..\..\..\..\..\uC-Serial\Driver\Atmel\; ..\..\..\..\..\uC-Serial\Line; ..\..\..\..\..\uC-Serial\OS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uCOS-III-Ex1.srec
  ILINK.IlinkOutputFile: OS.out
  ILINK.IlinkIcfFile: ..\..\BSP\IAR\AT91SAM9M10_SRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: APP_CFG_DDRAM_EN
  ILINK.IlinkOutputFile: OS-Probe-Serial.out
  ILINK.IlinkIcfFile: ..\..\BSP\IAR\AT91SAM9M10_DDRAM.icf
  ILINK.IlinkExtraOptions: --no_remove
  group APP
    ../: app.c app_cfg.h app_hooks.c includes.h lib_cfg.h os_cfg.h
  group BSP
    ../../BSP/: bsp.c bsp.h
  group BSP/IAR
    ../../BSP/IAR/: AT91SAM9M10_DDRAM.icf AT91SAM9M10_DDRAM.mac AT91SAM9M10_SRAM.icf AT91SAM9M10_SRAM.mac cstartup.s
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/LIB/ARM/IAR
    ../../../../../uC-LIB/Ports/ARM/IAR/: lib_mem_a.asm
  group uC/OS-II/Ports/ARM/Generic/IAR
    ../../../../../uCOS-II/Ports/ARM/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c os_dcc.c
  group uC/OS-II/Source
    ../../../../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
